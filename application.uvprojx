# Keil uVision project application.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC824M201JDH20 NXP
  pack: Keil.LPC800_DFP.1.2.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: application +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: _KEIL_ARTX_, CORE_M0PLUS
  c include: SRC\lpc_chip\chip_common\; SRC\lpc_chip\chip_8xx\; SRC\lpc_chip\chip_8xx\config_82x
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Application
    ./SRC/: RTX_Conf_CM.c main.c MMI.C UART0.C
  group Peripherals
    ./SRC/lpc_chip/chip_8xx/: acmp_8xx.c adc_8xx.c clock_8xx.c crc_8xx.c dma_8xx.c gpio_8xx.c i2c_common_8xx.c i2cm_8xx.c i2cs_8xx.c iocon_8xx.c irc_8xx.c pinint_8xx.c pmu_8xx.c sct_8xx.c sct_pwm_8xx.c spi_8xx.c spim_8xx.c spis_8xx.c stopwatch_8xx.c swm_8xx.c syscon_8xx.c uart_8xx.c wkt_8xx.c wwdt_8xx.c
    ./SRC/lpc_chip/chip_common/: eeprom.c iap.c ring_buffer.c rtc_ut.c
software components: Device:Startup 1.0.0
