# IAR project lib_lpc_chip_82x.ewp, settings and files
configuration chip_82x_lib (ARM, debug)
  General.OGChipSelectEditMenu: LPC824M201 NXP LPC824M201
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CORE_M0PLUS
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; config_82x; ../chip_common; ../../../CMSIS/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lib_lpc_chip_82x.out
  group chip_82x
    ./: acmp_8xx.c adc_8xx.c chip_8xx.c clock_8xx.c crc_8xx.c dma_8xx.c gpio_8xx.c i2c_common_8xx.c i2cm_8xx.c i2cs_8xx.c iocon_8xx.c irc_8xx.c pinint_8xx.c pmu_8xx.c sct_8xx.c sct_pwm_8xx.c spi_8xx.c spim_8xx.c spis_8xx.c stopwatch_8xx.c swm_8xx.c syscon_8xx.c sysinit_8xx.c uart_8xx.c wkt_8xx.c wwdt_8xx.c
    ../chip_common/: iap.c ring_buffer.c
